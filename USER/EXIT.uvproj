# Keil uVision project EXIT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EXIT +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\TIMER;..\HARDWARE\SPI;..\HARDWARE\AM2305;..\HARDWARE\MAX31865;..\HARDWARE\SY-FSX2;..\HARDWARE\RESPONSE;..\HARDWARE\DAC;..\HARDWARE\ADC;..\HARDWARE\PLUSE_ENCODE;..\HARDWARE\RS485;..\HARDWARE\AWA5632;..\HARDWARE\DS18B20;..\HARDWARE\OPC;..\MODBUS_SLAVE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/AM2305/: am2305.c
    ../HARDWARE/MAX31865/: max31865.c
    ../HARDWARE/SY-FSX2/: fsx2.c
    ../HARDWARE/RESPONSE/: response.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/OPC/: opc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dac.c
  group MODBUS
    ../MODBUS_SLAVE/: mbcrc.c modbus_slave.c
